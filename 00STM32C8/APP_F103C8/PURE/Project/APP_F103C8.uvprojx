# Keil uVision project APP_F103C8.uvprojx, settings and files
target APP_F103C8_Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: release +hex
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\BSP;..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group USER
    ../User/: main.c stm32f10x_it.c
    ../../BSP/: bsp_common.c bsp_common.h bsp_usart.c bsp_usart.h bsp_timer.c bsp_timer.h bsp_delay.c bsp_delay.h bsp_gpio.c bsp_gpio.h bsp_sys.c bsp_sys.h bsp_wifi.c bsp_wifi.h bsp_oled.c bsp_oled.h bsp_dht22.c bsp_dht22.h bsp_adc.c bsp_adc.h
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
target APP_F103C8_Update (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: release +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin -o ../Output/release.bin ../Output/release.axf
  AfterMake: MergeHex.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,DUISHE_SYS_UPDATE
  c include: ..\..\BSP;..\Libraries\CMSIS;..\Libraries\FWLIB\inc;..\User;..\..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
