# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: release +hex
  AfterMake: CopyHex.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Lib\inc;..\CMSIS;..\..\BSP;..\User\startup\arm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../User/startup/arm/: startup_stm32f10x_md.s
  group BSP
    ../../BSP/: gprs.c gprs.h key.c key.h SysTick.c SysTick.h timer.c timer.h usart.c usart.h
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_it.h includes.h
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../User/: core_cm3.c system_stm32f10x.c
